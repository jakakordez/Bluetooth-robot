# Keil uVision project Bluetooth robot.uvprojx, settings and files
target Bluetooth robot Configuration (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Bluetooth robot Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F3xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\Drivers\BSP\Components\lsm303dlhc;..\Drivers\BSP\Components\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303xc.s
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc.c stm32f3xx_hal.c stm32f3xx_hal_flash.c stm32f3xx_hal_dma.c
  group Application/User
    ../Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c motor.c
